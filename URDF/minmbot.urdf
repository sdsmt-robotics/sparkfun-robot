Commit message: Update minmbot.urdf

File: URDF/minmbot.urdf (robot description, URDF)
Before this commit: robot minmbot, 9 links, 8 joints
Joints:
- removed joint base_footprint_to_base_link_joint
